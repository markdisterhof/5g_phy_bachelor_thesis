options:
  parameters:
    author: Mark Disterhof
    copyright: Mark Disterhof
    generate_options: qt_gui
    id: nr_sync_simulation
    output_language: python
    title: nr_sync_simulation
  states: {}

blocks:
- name: N_ID1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: N_ID2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: N_RB
  id: variable
  parameters:
    value: '40'
  states: {}
- name: f
  id: variable
  parameters:
    value: '0'
  states: {}
- name: k_ssb
  id: variable
  parameters:
    value: '0'
  states: {}
- name: mu
  id: variable
  parameters:
    value: '1'
  states: {}
- name: num_carr
  id: variable
  parameters:
    value: N_RB *12
  states: {}
- name: paired_spectr
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: pbch_data
  id: variable
  parameters:
    value: '[0]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32000//2
  states: {}
- name: shared_spectr
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: num_carr
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: num_carr
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_carr
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_carr
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: num_carr
    type: complex
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: num_carr
    len_tag_key: '"packet_len"'
    occupied_carriers: '[np.arange(-1,num_carr, dtype=np.int32).tolist()]'
    output_is_shifted: 'True'
    pilot_carriers: '[[0]]'
    pilot_symbols: '[[0+0*1j],]'
    sync_words: '[list(np.array([1+ 1j for x in range(num_carr)],dtype=np.complex64))]'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: num_carr
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(num_carr)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: num_carr
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(num_carr)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: nr_sync_generate_rgrid_c_0_0
  id: nr_sync_generate_rgrid_c
  parameters:
    N_ID1: N_ID1
    N_ID2: N_ID2
    N_RB: N_RB
    f: f
    k_ssb: k_ssb
    mu: mu
    paired_spectr: 'False'
    pbch_data: '[0]'
    shared_spectr: 'True'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"ofdmmod"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"ofdmmod"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ofdm_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: ofdm_out
  states: {}

connections:
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [blocks_throttle_0, '0', blocks_vector_to_stream_0_1, '0']
- [blocks_vector_to_stream_0_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_vector_to_stream_0_0_0_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [blocks_vector_to_stream_0_1, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_vector_to_stream_0_1, '0', qtgui_const_sink_x_1, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', blocks_vector_to_stream_0_0_0_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', virtual_sink_0, '0']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [nr_sync_generate_rgrid_c_0_0, '0', blocks_throttle_0, '0']
- [virtual_source_0, '0', fft_vxx_0_0, '0']

metadata:
  file_format: 1
