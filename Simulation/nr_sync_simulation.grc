options:
  parameters:
    author: Mark Disterhof
    copyright: Mark Disterhof
    generate_options: qt_gui
    id: nr_sync_dem
    output_language: python
    title: 5G NR Synchronization Procedure Demo
  states: {}

blocks:
- name: L__max
  id: variable
  parameters:
    value: len(idxs)
  states: {}
- name: N_ID1
  id: variable
  parameters:
    value: '321'
  states: {}
- name: N_ID2
  id: variable
  parameters:
    value: '2'
  states: {}
- name: N_RB
  id: variable
  parameters:
    value: '30'
  states: {}
- name: f
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: idxs
  id: variable
  parameters:
    value: nr_phy_sync.nrSSB.get_ssb_idxs(nr_phy_sync.nrSSB.get_ssb_candidate_idx(mu, f, shared_spectr, paired_spectr), mu, shared_spectr)
  states: {}
- name: k_ssb
  id: variable
  parameters:
    value: '10'
  states: {}
- name: mu
  id: variable
  parameters:
    value: '0'
  states: {}
- name: num_carr
  id: variable
  parameters:
    value: N_RB *12
  states: {}
- name: num_cp
  id: variable
  parameters:
    value: num_carr//4
  states: {}
- name: paired_spectr
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: pbch_data
  id: variable
  parameters:
    value: '[0]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: shared_spectr
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    label: threhold
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: '0.9'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/num_carr
    type: complex
  states: {state: bypassed}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: '144'
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: int
    vlen: '864'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1'
    type: complex
    vlen: num_carr
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1'
    type: complex
    vlen: num_carr
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_carr
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_carr
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '200'
    type: complex
    vlen: num_carr
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_carr
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_carr
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: 240*4
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: num_carr
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: num_carr
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0001'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {state: bypassed}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: num_carr
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(num_carr)
  states: {state: bypassed}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: num_carr
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(num_carr)
  states: {state: bypassed}
- name: import_0
  id: import
  parameters:
    imports: import nr_phy_sync
  states: {}
- name: nr_sync_nidcell_ii_0
  id: nr_sync_nidcell_ii
  parameters: {}
  states: {}
- name: nr_sync_pbch_descramble_ci_0
  id: nr_sync_pbch_descramble_ci
  parameters:
    L__max: L__max
  states: {}
- name: nr_sync_pss_detector_cc_0
  id: nr_sync_pss_detector_cc
  parameters:
    L__max: L__max
    N_RB: N_RB
    threshold: threshold
  states: {}
- name: nr_sync_rgrid_c_0
  id: nr_sync_rgrid_c
  parameters:
    N_ID1: N_ID1
    N_ID2: N_ID2
    N_RB: N_RB
    f: f
    k_ssb: k_ssb
    mu: mu
    paired_spectr: paired_spectr
    pbch_data: pbch_data
    shared_spectr: shared_spectr
  states: {}
- name: nr_sync_sss_decode_ci_0
  id: nr_sync_sss_decode_ci
  parameters: {}
  states: {}
- name: nr_sync_unmap_ssb_cc_0
  id: nr_sync_unmap_ssb_cc
  parameters:
    nu: (N_ID2 + 3* N_ID1)%4
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,1,1,1)
    name: '"Rx Constellation"'
    size: num_carr
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (1,1,1,1)
    name: '"Rx SSB Constellation"'
    size: 240*4
    type: complex
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: (1,0,1,1)
    name: '"Rx Resourcegrid"'
    ncols: num_carr
    nrows: '50'
    samp_rate: samp_rate
    type: float
  states: {}
- name: qtgui_time_raster_sink_x_0_1
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: (0,0,1,1)
    name: '"Tx Resourcegrid"'
    ncols: num_carr
    nrows: '50'
    samp_rate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: modulation_chain
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: channel
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: demod_chain
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx_grid
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: modulation_chain
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: channel
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: demod_chain
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: rx_grid
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_time_raster_sink_x_0_1, '0']
- [blocks_multiply_const_xx_0, '0', virtual_sink_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_vector_to_stream_0_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', virtual_sink_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', virtual_sink_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', virtual_sink_0_0_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_complex_to_real_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_vector_to_stream_0_1, '0', blocks_complex_to_real_0_0, '0']
- [blocks_vector_to_stream_0_2, '0', blocks_add_xx_0, '0']
- [channels_channel_model_0, '0', blocks_stream_to_vector_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_0_2, '0']
- [nr_sync_nidcell_ii_0, '0', nr_sync_pbch_descramble_ci_0, '0']
- [nr_sync_pbch_descramble_ci_0, '0', blocks_null_sink_1_0, '0']
- [nr_sync_pss_detector_cc_0, '0', nr_sync_nidcell_ii_0, '0']
- [nr_sync_pss_detector_cc_0, '0', nr_sync_sss_decode_ci_0, '0']
- [nr_sync_pss_detector_cc_0, '1', blocks_vector_to_stream_0_0_0, '0']
- [nr_sync_pss_detector_cc_0, '1', nr_sync_unmap_ssb_cc_0, '0']
- [nr_sync_pss_detector_cc_0, '2', nr_sync_unmap_ssb_cc_0, '1']
- [nr_sync_rgrid_c_0, '0', blocks_throttle_0, '0']
- [nr_sync_sss_decode_ci_0, '0', nr_sync_nidcell_ii_0, '1']
- [nr_sync_unmap_ssb_cc_0, '0', nr_sync_sss_decode_ci_0, '1']
- [nr_sync_unmap_ssb_cc_0, '1', nr_sync_pbch_descramble_ci_0, '1']
- [nr_sync_unmap_ssb_cc_0, '2', nr_sync_pbch_descramble_ci_0, '2']
- [nr_sync_unmap_ssb_cc_0, '3', blocks_null_sink_1, '0']
- [virtual_source_0, '0', fft_vxx_0, '0']
- [virtual_source_0_0, '0', channels_channel_model_0, '0']
- [virtual_source_1, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [virtual_source_2, '0', nr_sync_pss_detector_cc_0, '0']

metadata:
  file_format: 1
