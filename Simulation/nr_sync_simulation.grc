options:
  parameters:
    author: Mark Disterhof
    copyright: Mark Disterhof
    generate_options: qt_gui
    id: nr_sync_simulation
    output_language: python
    title: nr_sync_simulation
  states: {}

blocks:
- name: N_ID1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: N_ID2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: N_RB
  id: variable
  parameters:
    value: '40'
  states: {}
- name: f
  id: variable
  parameters:
    value: '0'
  states: {}
- name: k_ssb
  id: variable
  parameters:
    value: '0'
  states: {}
- name: mu
  id: variable
  parameters:
    value: '1'
  states: {}
- name: num_carr
  id: variable
  parameters:
    value: N_RB *12
  states: {}
- name: paired_spectr
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: pbch_data
  id: variable
  parameters:
    value: '[0]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: shared_spectr
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_carr
    type: complex
  states: {}
- name: nr_sync_generate_rgrid_c_0
  id: nr_sync_generate_rgrid_c
  parameters:
    N_ID1: N_ID1
    N_ID2: N_ID2
    N_RB: N_RB
    f: f
    k_ssb: k_ssb
    mu: mu
    paired_spectr: 'False'
    pbch_data: '[0]'
    shared_spectr: 'True'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: num_carr
    srate: '1'
    type: complex
    ymax: '20'
    ymin: '-20'
  states: {}

connections:
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [nr_sync_generate_rgrid_c_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
