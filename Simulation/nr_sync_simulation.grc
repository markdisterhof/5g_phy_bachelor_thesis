options:
  parameters:
    generate_options: qt_gui
    id: nr_sync_simulation
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: nr_sync_generate_rgrid_c_0
  id: nr_sync_generate_rgrid_c
  parameters:
    N_ID1: '0'
    N_ID2: '1'
    N_RB: '20'
    f: '0'
    k_ssb: '0'
    mu: '1'
    paired_spectr: 'False'
    pbch_data: '[0]'
    shared_spectr: 'True'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [nr_sync_generate_rgrid_c_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
